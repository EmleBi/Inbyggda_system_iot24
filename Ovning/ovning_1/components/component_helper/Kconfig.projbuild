## Ovning/ovning_1/components/component_helper/Kconfig.projbuild
```kconfig
menu "Printer configuration"
    config PRINT_LEVEL
        int 
        default 0
    
endmenu
```
